# Keil uVision project gpio.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F030R8 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x2000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: gpio +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\Include;.\User;.\FATFS
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group User
    ./User/: main.c lcd.c spi1.c Fonts.c delay.c touch.c MMC_SD.C fatfs_storage.c
  group Startup
    ./Startup/: startup_stm32f030x8.s system_stm32f0xx.c
  group Include
    ./Include/: cmsis_armcc.h cmsis_compiler.h cmsis_version.h core_cm0.h stdint.h stm32f0xx.h stm32f030x8.h system_stm32f0xx.h
  group FATFS
    ./FATFS/: diskio.c ff.c
