# Keil uVision project gpio.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F030R8 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x2000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: gpio +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\Include;.\User;.\FreeRTOS\include;.\FreeRTOS\portable\RVDS\ARM_CM0
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group User
    ./User/: main.c flash_as_eeprom.c
  group Startup
    ./Startup/: startup_stm32f030x8.s system_stm32f0xx.c
  group Include
    ./Include/: cmsis_armcc.h cmsis_compiler.h cmsis_version.h core_cm0.h stdint.h stm32f0xx.h stm32f030x8.h system_stm32f0xx.h
    ./User/: FreeRTOSConfig.h
  group FreeRTOS
    ./FreeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ./FreeRTOS/portable/MemMang/: heap_2.c
    ./FreeRTOS/portable/RVDS/ARM_CM0/: port.c
