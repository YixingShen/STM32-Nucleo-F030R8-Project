# Keil uVision project STM32F0-FreeRTOS.uvproj, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F030R8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: STM32F0 +hex
  c flags: Optim=1 oTime=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F030,
  c misc: --c99 --diag-suppress 111
  c include: .\src\User_Files;.\src\Official_Files\FreeRTOS_V8_1_2\Source;.\src\Official_Files\FreeRTOS_V8_1_2\Source\include;.\src\Official_Files\FreeRTOS_V8_1_2\Source\portable\MemMang;.\src\Official_Files\FreeRTOS_V8_1_2\Source\portable\RVDS\ARM_CM0;.\Libraries\CMSIS\Include;.\Libraries\STM32F0xx_StdPeriph_Driver\inc;.\Libraries\CMSIS\Device\ST\STM32F0xx\Include;.\src\Official_Files\FreeRTOS_V8_1_2\Source\include;.\src\Official_Files\FreeRTOS_V8_1_2\Source\portable\RVDS\ARM_CM0;.\src\Official_Files\FreeRTOS_V8_1_2\Source\include;.\Libraries\STM32F0xx_StdPeriph_Driver
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group User
    ./src/User_Files/: main.c stm32f0xx_it.c GPIO.C system_time.c
  group FreeRTOS
    ./src/Official_Files/FreeRTOS_V8_1_2/Source/portable/MemMang/: heap_2.c
    ./src/Official_Files/FreeRTOS_V8_1_2/Source/: timers.c tasks.c queue.c list.c croutine.c
  group STM32F0xx_StdPeriph_Driver
    ./Libraries/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_adc.c stm32f0xx_can.c stm32f0xx_cec.c stm32f0xx_comp.c stm32f0xx_crc.c stm32f0xx_crs.c stm32f0xx_dac.c stm32f0xx_dbgmcu.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_wwdg.c
  group CM0
    ./src/Official_Files/FreeRTOS_V8_1_2/Source/: FreeRTOSConfig.h
    ./src/Official_Files/FreeRTOS_V8_1_2/Source/portable/RVDS/ARM_CM0/: port.c
    ./Libraries/CMSIS/Device/ST/STM32F0xx/Source/Templates/: system_stm32f0xx.c
    ./Libraries/CMSIS/Device/ST/STM32F0xx/Source/Templates/arm/: startup_stm32f030.s
